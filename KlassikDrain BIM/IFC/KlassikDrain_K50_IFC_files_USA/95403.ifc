Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: fa65b50d-f803-4be6-9692-1e0c1ed2405c, VersionGUID: 330ce961-59b5-483c-88fb-fc292a08b31a, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 95403.ifc
Time: 2026-08-17T17:51:34+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.60.12 (ENU) - IFC 24.3.60.12

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:1/4" Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (ft)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 10

# IfcFlowTerminal: ZZZ_do not use_PF_ST_MiniKlassik_K50_endcaps_USA_ACO:std(nested), ZZZ_do not use_PF_ST_MiniKlassik_K50_endcaps_USA_ACO:std(nested):388246
In: Level 1
Type - Description: K50/KS50 Galvanized end cap; PredefinedType: USERDEFINED; Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
MiniKlassik K50/KS50 Schedule - RSen_C_code_article: 95403; RSen_C_description: KS50 Stainless end cap; RSen_S_net_mass: 0.2 kg; URL: www.acousa.com; Description: K50/KS50 Galvanized end cap; Manufacturer: ACO; productrange: KlassikDrain; OmniClass Title: Rainwater Removal; RSen_C_info_commercial: https://www.acousa.com/products/stormwater-management/commercial-trench-drains/general-purpose-drains/miniklassik-k50-ks50/; RSen_C_info_technical: https://www.acousa.com/products/stormwater-management/commercial-trench-drains/general-purpose-drains/miniklassik-k50-ks50/; RSen_C_content_creator: ACO Technology Centre, INDIA

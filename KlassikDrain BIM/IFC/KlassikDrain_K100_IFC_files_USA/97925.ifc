Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: a730342e-7c8c-4e32-bb11-232d831df79d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 97925.ifc
Time: 2026-02-23T16:21:43+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 in
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (in) = Constraints, Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcDistributionPort (11)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_365523_1
OutPort_365523_2
OutPort_365523_3
OutPort_365523_4
OutPort_365523_5
OutPort_365523_6
OutPort_365523_7
OutPort_365523_8
OutPort_365523_9
OutPort_365523_10
OutPort_365523_11

# IfcFlowTerminal: KlassikDrain_K1-632G_Catch_basin_USA:K1-632G Catch Basin, KlassikDrain_K1-632G_Catch_basin_USA:K1-632G Catch Basin:365523
In: Level 1
Type - Description: K1-632G catch basin w/ polymer concrete riser & base; PredefinedType: USERDEFINED; Material: polymer concrete, Steel, Galvanised
Type - Other - Category: Plumbing Fixtures; Family Name: KlassikDrain_K1-632G_Catch_basin_USA; material_index: 1
Type - Constraints - Default Elevation: 0 in
Type - Dimensions - void_width_01: 10.0394 in; void_width_02: 18.5039 in
Type - General - installation_manual: https://acoswm.com/drain/klassikdrain/k100/; instructions_for_use: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 19-01-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_intended_use: Drainage systems
Type - Identity Data - Address: ACO, Inc. USA; Cost: 0; desc_uk: K1-632G catch basin w/ polymer concrete riser & base; Description: K1-632G catch basin w/ polymer concrete riser & base; email sales: info@acousa.com; email Technical: info@acousa.com; Manufacturer: ACO; Model: K100/KS100 Catch Basin (0.5m); OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Name: K1-632G Catch Basin; URL: www.acousa.com
Type - Materials and Finishes - RSen_C_material: Steel, Galvanised; RSen_C_material_01: polymer concrete; RSen_C_material_02: PE, Black
Type - Text - lookup_table_name: K1_632G_Catch_basin
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: K1-632G Catch Basin; sets with these values: 2
Other - Family: KlassikDrain_K1-632G_Catch_basin_USA; Family and Type: KlassikDrain_K1-632G_Catch_basin_USA: K1-632G Catch Basin; Type: K1-632G Catch Basin; Type Id: 365503; universal_endcap_left: no; universal_endcap_right: no
Constraints - Elevation from Level: 0 in; gratings: K100_12_inch_wide_catch_basin_gratings : Series_600_Grates_DrainLok; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 in; QuickLok_Locking_Bar: yes; RSen_C_length_02: 19.685 in
Dimensions - Area: 1.53312 m2; cap thickness: 0.0787402 in; h1: 8.77953 in; h2: 8.85827 in; rail: 0.984252 in; RSen_C_diameter_P_c03: 7.87402 in; RSen_C_width_01: 14.1732 in; RSen_C_width_02: 3.93701 in; RSen_C_width_03: 13.937 in; RSen_C_width_04: 14.1732 in; Volume: 0.1165 m3
General - RSen_P_c01_diameter: 3.93701 in; RSen_P_c02_diameter: 5.90551 in
Identity Data - Mark: 9; productrange: KlassikDrain; RSen_C_code_article: 97925; RSen_C_code_gtin: -; RSen_C_description: K1-632G catch basin w/ polymer concrete riser & base
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 83 kg

# IfcFlowTerminal: ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings:std(nested), ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings:std(nested):365524
In: Level 1
Type - Material: <Unnamed>
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings
Type - Constraints - Default Elevation: 0 in
Type - Dimensions - length: 19.2913 in; width: 13.7795 in
Type - General - RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 14-01-2026
Type - Identity Data - Type Name: std(nested); URL: www.acousa.com
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - Family: ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings; Family and Type: ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings: std(nested); Type: std(nested); type_index: 1; Type Id: 365387
Constraints - Elevation from Level: 0 in; Level: Level 1; Offset from Host: 0 in; Host: Level : Level 1; Moves With Nearby Elements: no
Dimensions - Area: 0.1967 m2; Volume: 0.005145 m3
Identity Data - Mark: 10; RSen_C_code_article: 0; RSen_C_description: Series 600 Grates DrainLok
Phasing - Phase Created: New Construction

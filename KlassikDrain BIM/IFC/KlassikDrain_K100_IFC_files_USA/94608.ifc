Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 536b80a2-51c1-4b85-9e66-e3c5c6cad1d9, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 94608.ifc
Time: 2026-02-23T10:38:15+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 in
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (in) = Constraints, Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcDistributionPort (15)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_359324_1
OutPort_359324_2
OutPort_359324_3
OutPort_359324_4
OutPort_359324_5
OutPort_359324_6
OutPort_359324_7
OutPort_359324_8
OutPort_359324_9
OutPort_359324_10
OutPort_359324_11
OutPort_359324_12
OutPort_359324_13
OutPort_359324_14
OutPort_359324_15

# IfcFlowTerminal: KlassikDrain_K1-901G_In-line_pit_USA:K1-901G In-Line Catch Basin, KlassikDrain_K1-901G_In-line_pit_USA:K1-901G In-Line Catch Basin:359324
In: Level 1
Type - Description: K1-901G In-Line catch basin w/ plastic base; PredefinedType: USERDEFINED; Material: PE, Black, polymer concrete, Steel, Galvanised
Type - Other - Category: Plumbing Fixtures; Family Name: KlassikDrain_K1-901G_In-line_pit_USA; gm_type0: K100_inline_pit_gratings_USA : Type 442 Galvanized steel Brickslot - 19.69" (0.5 m); gm_type1: K100_inline_pit_gratings_USA : Type 482 Galvanized steel Brickslot access unit - 19.69" (0.5 m); gm_type2: K100_inline_pit_gratings_USA : Type 444 Stainless steel Brickslot - 19.69" (0.5 m); gm_type3: K100_inline_pit_gratings_USA : Type 484 Stainless steel Brickslot access unit - 19.69" (0.5 m); gm_type4: K100_inline_pit_gratings_USA : Type 471 Galvanized steel Brickslot - 19.69" (0.5 m); gm_type5: K100_inline_pit_gratings_USA : Type 483 Galvanized steel Brickslot access unit - 19.69" (0.5 m); gm_type6: K100_inline_pit_gratings_USA : Type 473 Stainless steel Brickslot - 19.69" (0.5 m); gm_type7: K100_inline_pit_gratings_USA : Type 485 Stainless steel Brickslot access unit - 19.69" (0.5 m); material_index: 1
Type - Constraints - Default Elevation: 0 in
Type - General - installation_manual: https://acoswm.com/drain/klassikdrain/k100/; instructions_for_use: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 18-11-2025; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_intended_use: Drainage systems
Type - Identity Data - Address: ACO, Inc. USA; Cost: 0; Description: K1-901G In-Line catch basin w/ plastic base; email sales: info@acousa.com; email Technical: info@acousa.com; Manufacturer: ACO; Model: K100/KS100 Catch Basin (0.5m); OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Name: K1-901G In-Line Catch Basin; URL: www.acousa.com
Type - Materials and Finishes - RSen_C_material: Steel, Galvanised; RSen_C_material_01: polymer concrete; RSen_C_material_02: PE, Black
Type - Text - lookuptable_name: K1-901G In-Line Catch Basin
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: K1-901G In-Line Catch Basin; sets with these values: 2
Other - DN_100_sanitary_check: no; DN_150_sanitary_check: yes; DN_sanitary: yes; Family: KlassikDrain_K1-901G_In-line_pit_USA; Family and Type: KlassikDrain_K1-901G_In-line_pit_USA: K1-901G In-Line Catch Basin; OD_sanitary: no; outlet_DN100: no; outlet_DN150: yes; Type: K1-901G In-Line Catch Basin; Type Id: 359302; universal_endcap_left: no; universal_endcap_right: no
Constraints - Elevation from Level: 0 in; Foul Air Trap: yes; gratings: K100_inline_pit_gratings_USA : Type 406D Galvanized mesh (0.5m); Host: Level : Level 1; Level: Level 1; Offset from Host: 0 in; QuickLok_Locking_Bar: yes; RSen_C_length_02: 19.685 in
Dimensions - Area: 1.03756 m2; Brickslot_height_calculated: 0 in; cap thickness: 0.0787402 in; h1: 8.77953 in; h2: 8.85827 in; r1: 0 in; rail: 0.984252 in; RSen_C_diameter_01: 2.95276 in; RSen_C_diameter_P_c03: 7.87402 in; RSen_C_width_01: 10.2362 in; RSen_C_width_02: 3.93701 in; RSen_C_width_03: 4.88189 in; RSen_C_width_04: 5.11811 in; Volume: 0.0781724 m3
General - RSen_P_c01_diameter: 3.93701 in; RSen_P_c02_diameter: 5.90551 in
Identity Data - Mark: 1; productrange: KlassikDrain; RSen_C_code_article: 94608; RSen_C_code_gtin: -; RSen_C_description: K1-901G In-Line catch basin w/ plastic base
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 23.85 kg

# IfcFlowTerminal: ZZZ_do not use_PF_ST_K100_pit_gratings_ACO_USA:std(nested), ZZZ_do not use_PF_ST_K100_pit_gratings_ACO_USA:std(nested):359325
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K100; Material: Steel, Galvanised
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_K100_pit_gratings_ACO_USA; lookup_table_name: Inline_pit_gratings_K100_CAN
Type - Constraints - Default Elevation: 0.333333 in
Type - Identity Data - Address: ACO, Inc. USA; Description: ACO Grating for KlassikDrain_K100; email-sales: info@acousa.com; email-Technical: info@acousa.com; LOD: LOD 300; Manufacturer: ACO; Model: Grating for KlassikDrain_K100; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Comments: --; Type Name: std(nested); URL: www.acousa.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - angle_left_calculated: 0 deg; angle_right_calculated: 0 deg; angle1_over_length_left: 0 in; angle1_over_length_right: 0 in; angle2_over_length_left: 0 in; angle2_over_length_right: 0 in; Brickslot_visible: no; Family: ZZZ_do not use_PF_ST_K100_pit_gratings_ACO_USA; Family and Type: ZZZ_do not use_PF_ST_K100_pit_gratings_ACO_USA: std(nested); Grate_visible: yes; IsCustom: no; length_01_C_ANZRS: 19.685 in; length_1000_check: no; length_500_check: no; length_calculated: 19.685 in; product_index: 15; RSen_C_width: 4.84252 in; Type: std(nested); type_index: 15; Type Id: 359082; visible: no
Constraints - Level: Level 1; Elevation from Level: 3.26772 in; Host: Level : Level 1; Moves With Nearby Elements: no; Offset from Host: 3.26772 in; RSen_C_angle_01: 0 deg; RSen_C_angle_02: 0 deg; RSen_C_length: 19.685 in; RSen_C_width_01: 4.84252 in
Dimensions - Brickslot_height_calculated: 0 in; angle_max: 90 deg; angle_min: -90 deg; Area: 0.126849 m2; Brickslot_width: 0.629921 in; D_L1: 19.685 in; D_L2: 19.685 in; D_R1: 39.3701 in; D_R2: 39.3701 in; insertion_point: 29.5276 in; U_L1: 19.685 in; U_L2: 19.685 in; U_R1: 39.3701 in; U_R2: 39.3701 in; Volume: 0.0009225 m3
General - RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 22-01-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_intended_use: https://acoswm.com/drain/klassikdrain/k100/
Identity Data - Mark: 2; productrange: KlassikDrain; RSen_C_code_article: 132881; RSen_C_description: Type 406D Galvanized mesh; Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Materials and Finishes - RSen_C_material: Steel, Galvanised
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 2.09 kg

Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: a730342e-7c8c-4e32-bb11-232d831df79d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 94631.ifc
Time: 2026-02-23T14:04:30+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 in
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (in) = Constraints, Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcDistributionPort (15)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_358269_1
OutPort_358269_2
OutPort_358269_3
OutPort_358269_4
OutPort_358269_5
OutPort_358269_6
OutPort_358269_7
OutPort_358269_8
OutPort_358269_9
OutPort_358269_10
OutPort_358269_11
OutPort_358269_12
OutPort_358269_13
OutPort_358269_14
OutPort_358269_15

# IfcFlowTerminal: KlassikDrain_K1-631G_Catch_basin_USA:K1-631G Catch Basin, KlassikDrain_K1-631G_Catch_basin_USA:K1-631G Catch Basin:358269
In: Level 1
Type - Description: K1-631G catch basin w/ plastic riser & base; PredefinedType: USERDEFINED; Material: PE, Black, polymer concrete, Steel, Galvanised
Type - Other - Category: Plumbing Fixtures; Family Name: KlassikDrain_K1-631G_Catch_basin_USA; material_index: 1
Type - Constraints - Default Elevation: 0 in
Type - Dimensions - catch_basin_topsection-height: 14.0157 in; void_width_01: 12.5984 in; void_width_02: 18.5039 in
Type - General - installation_manual: https://acoswm.com/drain/klassikdrain/k100/; instructions_for_use: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 19-01-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_intended_use: Drainage systems
Type - Identity Data - Address: ACO, Inc. USA; Cost: 0; desc_uk: K1-631G catch basin w/ plastic riser & base; Description: K1-631G catch basin w/ plastic riser & base; email sales: info@acousa.com; email Technical: info@acousa.com; Manufacturer: ACO; Model: K100/KS100 Catch Basin(0.5m); OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Name: K1-631G Catch Basin; URL: www.acousa.com
Type - Materials and Finishes - RSen_C_material: Steel, Galvanised; RSen_C_material_01: polymer concrete; RSen_C_material_02: PE, Black
Type - Text - lookup_table_name: K1_631G_Catch_basin
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: K1-631G Catch Basin; sets with these values: 2
Other - Family: KlassikDrain_K1-631G_Catch_basin_USA; Family and Type: KlassikDrain_K1-631G_Catch_basin_USA: K1-631G Catch Basin; Plastic_riser_cutting_size: 4; Riser_Depth_calculated: 7.87402 in; Type: K1-631G Catch Basin; Type Id: 358226; universal_endcap_left: no; universal_endcap_right: no
Constraints - Elevation from Level: 0 in; Foul_Air_Trap: yes; gratings: K100_12_inch_wide_catch_basin_gratings : Series_600_Grates_DrainLok; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 in; QuickLok_Locking_Bar: yes; Riser_Depth: 7.87402 in; Riser_Visibility: yes; RSen_C_length_02: 19.685 in
Dimensions - Area: 1.23015 m2; cap thickness: 0.0787402 in; h1: 8.77953 in; h2: 8.85827 in; rail: 0.984252 in; RSen_C_diameter_P_c03: 7.87402 in; RSen_C_width_01: 14.1732 in; RSen_C_width_02: 3.93701 in; RSen_C_width_03: 13.937 in; RSen_C_width_04: 14.1732 in; Volume: 0.0812882 m3
General - RSen_P_c01_diameter: 3.93701 in; RSen_P_c02_diameter: 5.90551 in
Identity Data - Mark: 1; productrange: KlassikDrain; RSen_C_code_article: 94631; RSen_C_code_gtin: -; RSen_C_description: K1-631G catch basin w/ plastic riser & base
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 29.84 kg

# IfcFlowTerminal: ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings:std(nested), ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings:std(nested):358275
In: Level 1
Type - Material: <Unnamed>
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings
Type - Constraints - Default Elevation: 0 in
Type - Dimensions - length: 19.2913 in; width: 13.7795 in
Type - General - RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 14-01-2026
Type - Identity Data - Type Name: std(nested); URL: www.acousa.com
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - Type: std(nested); Family: ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings; Family and Type: ZZZ_do not use_K100_12_inch_wide_catch_basin_gratings: std(nested); type_index: 1; Type Id: 358061
Constraints - Elevation from Level: 0 in; Level: Level 1; Offset from Host: 0 in; Moves With Nearby Elements: no; Host: Level : Level 1
Dimensions - Area: 0.1967 m2; Volume: 0.005145 m3
Identity Data - Mark: 7; RSen_C_code_article: 0; RSen_C_description: Series 600 Grates DrainLok
Phasing - Phase Created: New Construction

# IfcFlowTerminal: ZZZ_do not use_PF_ST_K100_plastic_riser:std(nested) (4)
In: Level 1
Type - Description: Series 600 Plastic Riser; Material: PE, Black
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_K100_plastic_riser
Type - Constraints - Default Elevation: 0 in
Type - Dimensions - r1: 0.19685 in; RSen_C_width_01: 13.7795 in; RSen_C_width_02: 7.87402 in; RSen_C_width_03: 9.92126 in; RSen_C_width_04: 9.33071 in
Type - General - installation_manual: https://acoswm.com/drain/klassikdrain/; instructions_for_use: https://acoswm.com/drain/klassikdrain/; RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 13-01-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/; RSen_C_intended_use: Drainage systems
Type - Identity Data - Address: ACO, Inc. USA; Description: Series 600 Plastic Riser; email sales: info@acousa.com; email Technical: info@acousa.com; Manufacturer: ACO; Model: Series 600 Plastic Riser; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Name: std(nested); URL: www.acousa.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - material_index: 1; Family: ZZZ_do not use_PF_ST_K100_plastic_riser; Family and Type: ZZZ_do not use_PF_ST_K100_plastic_riser: std(nested); product_index: 1; Riser_visibility: yes; Type: std(nested); Type Id: 358077
Constraints - Level: Level 1; Host: Level : Level 1; Moves With Nearby Elements: no; RSen_C_length_02: 19.2913 in
Dimensions - Area: 0.22277 m2; h2: 12.7953 in; rail: 0.984252 in; Riser_depth: 1.65354 in; Volume: 0.010303 m3
Identity Data - productrange: KlassikDrain; RSen_C_code_article: 99902; RSen_C_description: Series 600 Plastic Riser
Materials and Finishes - RSen_C_material: PE, Black
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 4.53 kg
Name (ZZZ_do not use_PF_ST_K100_plastic_riser:std(nested):...) | Elevation from Level (in) = Offset from Host (in) | Mark
358270 | -21.321 | 2
358271 | -18.8805 | 3
358272 | -16.4401 | 4
358273 | -13.9996 | 5

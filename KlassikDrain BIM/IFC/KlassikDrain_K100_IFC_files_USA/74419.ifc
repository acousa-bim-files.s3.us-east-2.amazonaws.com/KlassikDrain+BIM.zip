Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 2f2c36bd-32f3-4d00-b36c-6f182a6ec70f, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 74419.ifc
Time: 2026-02-20T16:40:02+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 in
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (in) = Constraints, Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcFlowTerminal: PF_ST_KlassikDrain_K100 & KS100_channels_USA_ACO:KlassikDrain_KS100_Invert_Depth_5.91 in to 7.83 in, PF_ST_KlassikDrain_K100 & KS100_channels_USA_ACO:KlassikDrain_KS100_Invert_Depth_5.91 in to 7.83 in:359320
In: Level 1
Type - Description: ACO KlassikDrain K100/KS100 channels; PredefinedType: USERDEFINED; Material: Steel, Stainless, polymer concrete
Type - Other - Category: Plumbing Fixtures; Family Name: PF_ST_KlassikDrain_K100 & KS100_channels_USA_ACO; gm_type0: KlassikDrain_K100_gratings_USA : Galvanised_Brickslot 100 (0.5m); gm_type1: KlassikDrain_K100_gratings_USA : Galvanised_Brickslot 100 (1m); gm_type10: KlassikDrain_K100_gratings_USA : Stainless_Heel-Resistant_Brickslot 100 (1m); gm_type11: KlassikDrain_K100_gratings_USA : Stainless_Heel-Resistant_Brickslot 100 access unit (0.5m); gm_type2: KlassikDrain_K100_gratings_USA : Galvanised_Brickslot 100 access unit (0.5m); gm_type3: KlassikDrain_K100_gratings_USA : Galvanised_Heel-Resistant_Brickslot 100 (0.5m); gm_type4: KlassikDrain_K100_gratings_USA : Galvanised_Heel-Resistant_Brickslot 100 (1m); gm_type5: KlassikDrain_K100_gratings_USA : Galvanised_Heel-Resistant_Brickslot 100 access unit (0.5m); gm_type6: KlassikDrain_K100_gratings_USA : Stainless_Brickslot 100 (0.5m); gm_type7: KlassikDrain_K100_gratings_USA : Stainless_Brickslot 100 (1m); gm_type8: KlassikDrain_K100_gratings_USA : Stainless_Brickslot 100 access unit (0.5m); gm_type9: KlassikDrain_K100_gratings_USA : Stainless_Heel-Resistant_Brickslot 100 (0.5m)
Type - Constraints - Default Elevation: 0.333333 in
Type - Identity Data - Address: ACO, Inc. USA; Description: ACO KlassikDrain K100/KS100 channels; email-sales: info@acousa.com; email-Technical: info@acousa.com; LOD: LOD 300; Manufacturer: ACO; Model: KlassikDrain K100/KS100 channels; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Comments: --; Type Name: KlassikDrain_KS100_Invert_Depth_5.91 in to 7.83 in; URL: www.acousa.com
Type - Materials and Finishes - RSen_C_material: Steel, Stainless; RSen_C_material_01: polymer concrete
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: KlassikDrain_KS100_Invert_Depth_5.91 in to 7.83 in; sets with these values: 2
Other - calculated_min_length: 10.1378 in; cut_radius: 5.90551 in; Family: PF_ST_KlassikDrain_K100 & KS100_channels_USA_ACO; Family and Type: PF_ST_KlassikDrain_K100 & KS100_channels_USA_ACO: KlassikDrain_KS100_Invert_Depth_5.91 in to 7.83 in; grating_position: 49.2126 in; height_index: 0; left_gratecut_length: 39.1339 in; length_01_C_ANZRS: 39.37 in; length_02_C_ANZRS: 39.37 in; length_calculated: 39.37 in; Neutral_channel_0.5m_check: 0; Neutral_channel_1m_check: 0; right_gratecut_length: 78.9763 in; RSen_C_width: 5.11811 in; Sloped_channel_check: 1; toggle_left_endcap: no; toggle_right_endcap: no; Type: KlassikDrain_KS100_Invert_Depth_5.91 in to 7.83 in; Type Id: 359275
Constraints - 19.68 in_grating: yes; 39.37 in_grating: no; channel_length_selection_warning ⚠️: ⚠️Channel length is restricted to a minimum of 11.08 inch and a maximum of 39.37 inch; Elevation from Level: 0 in; Grate removal tool: no; gratings: KlassikDrain_K100_gratings_USA : Type 460D Ductile iron slotted (0.5m); Invert_depth: 7.68 in; Invert_depth_selection_warning ⚠️: ⚠️Enter an Invert depth value ranging from 6.10 in to 7.87 in; K1 Installation device: no; Level: Level 1; Neutral_channel_0.5m: no; Neutral_channel_1m: no; Neutral_channel_selection_warning ⚠️: --; Offset from Host: 0 in; QuickLok Locking Bar: no; RSen_C_angle_01: 0 deg; RSen_C_angle_02: 0 deg; RSen_C_length: 39.37 in; Schedule Level: Level 1; Sloped_channel: yes; Universal_end_cap_left: no; Universal_end_cap_right: no; Work Plane: Level : Level 1
Dimensions - actual_length: 39.3701 in; angle_left_calculated: 0 deg; angle_max: 89 deg; angle_min: -89 deg; angle_right_calculated: 0 deg; Area: 0.519392 m2; Brickslot_height_calculated: 0 in; calculated_Invert_depth_check: 7.68 in; calculated_invert_depth_male: 7.67717 in; Diameter_01: 3.89764 in; invert_depth_female: 7.48031 in; left_angle_max: 180 deg; left_angle_min: 0 deg; overall_depth_male: 8.46457 in; right_angle_max: -180 deg; right_angle_min: 0 deg; Volume: 0.0111807 m3
General - RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 22-01-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/; RSen_C_intended_use: https://acoswm.com/drain/klassikdrain/
Identity Data - Mark: 1; productrange: KlassikDrain; RSen_C_code_article: 74419; RSen_C_description: KS1-19 Sloped channel – 39.37" (1 m); Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 19.3 kg
Text - lookup_table_name: KlassikDrain_K100_USA

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K100_gratings_USA_ACO:std(nested) (2)
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K100; Material: Ductile iron
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_KlassikDrain_K100_gratings_USA_ACO; lookup_table_name: gratings_K100_CAN
Type - Constraints - Default Elevation: 0.333333 in
Type - General - RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_intended_use: https://acoswm.com/drain/klassikdrain/k100/
Type - Identity Data - Address: ACO, Inc. USA; Description: ACO Grating for KlassikDrain_K100; email-sales: info@acousa.com; email-Technical: info@acousa.com; LOD: LOD 300; Manufacturer: ACO; Model: Grating for KlassikDrain_K100; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Comments: --; Type Name: std(nested); URL: www.acousa.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - angle_left_calculated: 0 deg; angle_right_calculated: 0 deg; angle1_over_length_left: 0 in; angle1_over_length_right: 0 in; angle2_over_length_left: 0 in; angle2_over_length_right: 0 in; Brickslot_visible: no; Family: ZZZ_do not use_PF_ST_KlassikDrain_K100_gratings_USA_ACO; Family and Type: ZZZ_do not use_PF_ST_KlassikDrain_K100_gratings_USA_ACO: std(nested); Grate_visible: yes; IsCustom: no; length_01_C_ANZRS: 19.685 in; length_1000_check: no; length_500_check: no; length_calculated: 19.685 in; product_index: 29; RSen_C_width: 4.84252 in; Type: std(nested); type_index: 29; Type Id: 358983; visible: no
Constraints - RSen_C_angle_01: 0 deg; RSen_C_angle_02: 0 deg; Elevation from Level: 3.27 in; Moves With Nearby Elements: no; Offset from Host: 3.27 in; RSen_C_length: 19.685 in; RSen_C_width_01: 4.84252 in
Dimensions - Brickslot_height_calculated: 0 in; angle_max: 90 deg; angle_min: -90 deg; Area: 0.126878 m2; Brickslot_width: 0.629921 in; insertion_point: 29.5276 in
General - RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 22-01-2026; RSen_C_content_version: 1.0
Identity Data - productrange: KlassikDrain; RSen_C_code_article: 12670; RSen_C_description: Type 460D Ductile iron slotted; Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Materials and Finishes - RSen_C_material: Ductile iron; RSen_C_material_01: Steel, Galvanised
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 3.63 kg
Name (ZZZ_do not use_PF_ST_KlassikDrain_K100_gratings_USA_ACO:std(nested):...) | D_L1 (in) = D_L2 (in) = U_L1 (in) = U_L2 (in) | D_R1 (in) = D_R2 (in) = U_R1 (in) = U_R2 (in) | Volume (m3) | Mark
359323 | 19.685 | 39.3701 | 0.0009225 | 4
361809 | 19.6851 | 39.37 | 0.000922496 | 24

Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 3f64dc4c-3645-4b22-834d-dc8bd078d13c, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 75032.ifc
Time: 2026-03-02T10:59:05+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 in
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (in) = Constraints, Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcFlowTerminal: PF_ST_KlassikDrain_K200 & KS200_channels_USA_ACO:KlassikDrain_K200_Invert_Depth_13.78 in to 15.75 in, PF_ST_KlassikDrain_K200 & KS200_channels_USA_ACO:KlassikDrain_K200_Invert_Depth_13.78 in to 15.75 in:359270
In: Level 1
Type - Description: ACO KlassikDrain K200/KS200 channels; PredefinedType: USERDEFINED; Material: Steel, Galvanised, polymer concrete
Type - Other - Category: Plumbing Fixtures; Family Name: PF_ST_KlassikDrain_K200 & KS200_channels_USA_ACO; gm_type0: KlassikDrain_K200_gratings_USA : Type 641 Galvanized steel Brickslot - 39.37" (1 m); gm_type1: KlassikDrain_K200_gratings_USA : Type 642 Galvanized steel Brickslot - 19.69" (0.5 m); gm_type10: KlassikDrain_K200_gratings_USA : Type 684 Stainless steel Brickslot access unit - 19.69" (0.5 m); gm_type11: KlassikDrain_K200_gratings_USA : Type 685 Stainless steel Brickslot access unit - 19.69" (0.5 m); gm_type2: KlassikDrain_K200_gratings_USA : Type 643 Stainless steel Brickslot - 39.37" (1 m); gm_type3: KlassikDrain_K200_gratings_USA : Type 644 Stainless steel Brickslot - 19.69" (0.5 m); gm_type4: KlassikDrain_K200_gratings_USA : Type 670 Galvanized steel Brickslot - 39.37" (1 m); gm_type5: KlassikDrain_K200_gratings_USA : Type 672 Galvanized steel Brickslot - 19.69" (0.5 m); gm_type6: KlassikDrain_K200_gratings_USA : Type 673 Stainless steel Brickslot - 39.37" (1 m); gm_type7: KlassikDrain_K200_gratings_USA : Type 674 Stainless steel Brickslot - 19.69" (0.5 m); gm_type8: KlassikDrain_K200_gratings_USA : Type 682 Galvanized steel Brickslot access unit - 19.69" (0.5 m); gm_type9: KlassikDrain_K200_gratings_USA : Type 683 Galvanized steel Brickslot access unit - 19.69" (0.5 m)
Type - Constraints - Default Elevation: 0.333333 in
Type - Identity Data - Address: ACO, Inc. USA; Description: ACO KlassikDrain K200/KS200 channels; LOD: LOD 300; Manufacturer: ACO; Model: KlassikDrain K200/KS200 channels; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Comments: --; Type Name: KlassikDrain_K200_Invert_Depth_13.78 in to 15.75 in; URL: www.acousa.com
Type - Materials and Finishes - RSen_C_material: Steel, Galvanised; RSen_C_material_01: polymer concrete
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: KlassikDrain_K200_Invert_Depth_13.78 in to 15.75 in; sets with these values: 2
Other - calculated_min_length: 19.4232 in; cut_radius: 10.6299 in; Family: PF_ST_KlassikDrain_K200 & KS200_channels_USA_ACO; Family and Type: PF_ST_KlassikDrain_K200 & KS200_channels_USA_ACO: KlassikDrain_K200_Invert_Depth_13.78 in to 15.75 in; grating_position: 59.0551 in; height_index: 0; left_gratecut_length: 39.1339 in; length_calculated: 39.37 in; Neutral_channel_0.5m_check: 0; Neutral_channel_1m_check: 0; right_gratecut_length: 78.9763 in; RSen_C_length_01: 39.37 in; RSen_C_length_02: 39.37 in; RSen_C_width: 9.84252 in; Sloped_channel_check: 1; toggle_left_endcap: no; toggle_right_endcap: no; Type: KlassikDrain_K200_Invert_Depth_13.78 in to 15.75 in; Type Id: 359235
Constraints - 19.68 in_grating: no; 39.37 in_grating: yes; channel_length_selection_warning ⚠️: ⚠️Channel length is restricted to a minimum of 19.68 inch and a maximum of 39.37 inch; Elevation from Level: 0 in; Grate removal tool: no; gratings: KlassikDrain_K200_gratings_USA : Type 647D Stainless longitudinal (1m); Installation device: no; Invert_depth: 14.17 in; Invert_depth_selection_warning ⚠️: ⚠️Enter an Invert depth value ranging from 13.98 in to 15.75 in; Level: Level 1; Neutral_channel_0.5m: no; Neutral_channel_1m: no; Neutral_channel_selection_warning ⚠️: --; Offset from Host: 0 in; QuickLok bar: no; RSen_C_angle_01: 0 deg; RSen_C_angle_02: 0 deg; RSen_C_length: 39.37 in; Schedule Level: Level 1; Sloped_channel: yes; Universal_end_cap_left: no; Universal_end_cap_right: no; Work Plane: Level : Level 1
Dimensions - actual_length: 39.3701 in; angle_left_calculated: 0 deg; angle_max: 89 deg; angle_min: -89 deg; angle_right_calculated: 0 deg; Area: 0.981421 m2; Brickslot_height_calculated: 0 in; calculated_Invert_depth_check: 14.17 in; calculated_invert_depth_male: 14.1732 in; channel_overall_width: 10.2362 in; Diameter_01: 3.89764 in; invert_depth_female: 13.9764 in; left_angle_max: 180 deg; left_angle_min: 0 deg; overall_depth_male: 15.1575 in; right_angle_max: -180 deg; right_angle_min: 0 deg; Volume: 0.0391593 m3
General - RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 24-12-2025; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/; RSen_C_intended_use: https://acoswm.com/drain/klassikdrain/
Identity Data - email-sales: info@acousa.com; email-Technical: info@acousa.com; Mark: 1; productrange: KlassikDrain; RSen_C_code_article: 75032; RSen_C_description: K2-32 Sloped channel – 39.37" (1 m); Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 53.4 kg
Text - lookup_table_name: KlassikDrain_K200_USA

# IfcFlowTerminal: ZZZ_do not use_PF_ST_K200_gratings_USA_ACO:std(nested), ZZZ_do not use_PF_ST_K200_gratings_USA_ACO:std(nested):359274
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K200; Material: Steel, Stainless
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_K200_gratings_USA_ACO; lookup_table_name: gratings_K200_CAN
Type - Constraints - Default Elevation: 0.333333 in
Type - General - RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/; RSen_C_intended_use: https://acoswm.com/drain/klassikdrain/
Type - Identity Data - Address: ACO, Inc. USA; Description: ACO Grating for KlassikDrain_K200; LOD: LOD 300; Manufacturer: ACO; Model: Grating for KlassikDrain_K200; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Comments: --; Type Name: std(nested); URL: www.acousa.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - angle_left_calculated: 0 deg; angle_right_calculated: 0 deg; angle1_over_length_left: 0 in; angle1_over_length_right: 0 in; angle2_over_length_left: 0 in; angle2_over_length_right: 0 in; Brickslot_visible: no; Family: ZZZ_do not use_PF_ST_K200_gratings_USA_ACO; Family and Type: ZZZ_do not use_PF_ST_K200_gratings_USA_ACO: std(nested); Grate_visible: yes; IsCustom: no; length_1000_check: no; length_500_check: no; length_calculated: 39.37 in; product_index: 1; RSen_C_length_01: 39.37 in; RSen_C_width: 9.37008 in; Type: std(nested); type_index: 1; Type Id: 358979; visible: no
Constraints - RSen_C_angle_01: 0 deg; RSen_C_angle_02: 0 deg; Elevation from Level: 3.26772 in; Moves With Nearby Elements: no; Offset from Host: 3.26772 in; RSen_C_length: 39.3701 in
Dimensions - Brickslot_height_calculated: 0 in; angle_max: 90 deg; angle_min: -90 deg; Area: 0.480971 m2; Brickslot_width: 0.629921 in; D_L1: 9.84256 in; D_L2: 9.84256 in; D_R1: 49.2126 in; D_R2: 49.2126 in; insertion_point: 29.5276 in; RSen_C_width_01: 9.37008 in; Twinslot_200_distance: 0 in; U_L1: 9.84256 in; U_L2: 9.84256 in; U_R1: 49.2126 in; U_R2: 49.2126 in; Volume: 0.00713999 m3
General - RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 23-01-2026; RSen_C_content_version: 1.0
Identity Data - email-sales: info@acocan.ca; email-Technical: info@acocan.ca; Mark: 5; productrange: KlassikDrain; RSen_C_code_article: 142219; RSen_C_description: Type 647D Stainless longitudinal; Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Materials and Finishes - RSen_C_material: Steel, Stainless
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 8.16 kg

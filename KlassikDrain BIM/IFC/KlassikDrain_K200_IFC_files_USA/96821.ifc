Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 3f64dc4c-3645-4b22-834d-dc8bd078d13c, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 96821.ifc
Time: 2026-03-02T12:20:53+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 in
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (in) = Constraints, Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcFlowTerminal: ZZZ_do not use_PF_ST_K200_endcaps_USA_ACO:std(nested), ZZZ_do not use_PF_ST_K200_endcaps_USA_ACO:std(nested):363023
In: Level 1
Type - Description: ACO KlassikDrain K200 / KS200 Endcaps; PredefinedType: USERDEFINED; Material: grey ABS
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_K200_endcaps_USA_ACO
Type - Constraints - Default Elevation: 0.333333 in
Type - General - installation_manual: https://acoswm.com/drain/klassikdrain/k200/; instructions_for_use: https://acoswm.com/drain/klassikdrain/k200/; RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/k200/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 25-11-2025; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/k200/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/k200/; RSen_C_intended_use: Drainage systems
Type - Identity Data - Address: ACO, Inc. USA; Description: ACO KlassikDrain K200 / KS200 Endcaps; email sales: info@acousa.com; email Technical: info@acousa.com; LOD: LOD 300; Manufacturer: ACO; Model: KlassikDrain K200 / KS200 Endcaps; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Name: std(nested); Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems; URL: www.acousa.com
Type - Materials and Finishes - RSen_C_material_01: grey ABS
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - Family: ZZZ_do not use_PF_ST_K200_endcaps_USA_ACO; Family and Type: ZZZ_do not use_PF_ST_K200_endcaps_USA_ACO: std(nested); RSen_C_height: 12.7953 in; Type: std(nested); Type Id: 362997; Visible: yes
Constraints - Elevation from Level: 0 in; Level: Level 1; Offset from Host: 0 in; RSen_C_width_01: 9.84252 in; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.0964138 m2; Volume: 0.000467695 m3
Identity Data - Mark: 27; productrange: KlassikDrain; RSen_C_code_article: 96821; RSen_C_code_gtin: -; RSen_C_description: K200/KS200 End cap
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 0.6 kg

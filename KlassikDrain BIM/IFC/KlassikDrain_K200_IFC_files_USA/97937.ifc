Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: d505bb93-9288-4e9b-8c69-b7034156cb0d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 97937.ifc
Time: 2026-03-02T14:20:16+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 in
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (in) = Constraints, Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcDistributionPort (10)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_367058_1
OutPort_367058_2
OutPort_367058_3
OutPort_367058_4
OutPort_367058_5
OutPort_367058_6
OutPort_367058_7
OutPort_367058_8
OutPort_367058_9
OutPort_367058_10

# IfcFlowTerminal: KlassikDrain_K2-906GS_Catch_basin_USA:K2-906G Catch Basin (0.5m), KlassikDrain_K2-906GS_Catch_basin_USA:K2-906G Catch Basin (0.5m):367058
In: Level 1
Type - Description: K2-906G In-Line catch basin w/ polymer concrete base; PredefinedType: USERDEFINED; Material: polymer concrete, PE, Black, Steel, Galvanised
Type - Other - Category: Plumbing Fixtures; Family Name: KlassikDrain_K2-906GS_Catch_basin_USA; gm_type1: KlassikDrain_K200_catch_basin_gratings_USA : Type 642 Galvanized steel Brickslot - 19.69" (0.5 m); gm_type2: KlassikDrain_K200_catch_basin_gratings_USA : Type 644 Stainless steel Brickslot - 19.69" (0.5 m); gm_type3: KlassikDrain_K200_catch_basin_gratings_USA : Type 672 Galvanized steel Brickslot - 19.69" (0.5 m); gm_type4: KlassikDrain_K200_catch_basin_gratings_USA : Type 674 Stainless steel Brickslot - 19.69" (0.5 m); gm_type5: KlassikDrain_K200_catch_basin_gratings_USA : Type 682 Galvanized steel Brickslot access unit - 19.69" (0.5 m); gm_type6: KlassikDrain_K200_catch_basin_gratings_USA : Type 683 Galvanized steel Brickslot access unit - 19.69" (0.5 m); gm_type7: KlassikDrain_K200_catch_basin_gratings_USA : Type 684 Stainless steel Brickslot access unit - 19.69" (0.5 m); gm_type8: KlassikDrain_K200_catch_basin_gratings_USA : Type 685 Stainless steel Brickslot access unit - 19.69" (0.5 m); material_index: 1
Type - Constraints - Default Elevation: 0 in; RSen_C_length_02: 19.685 in
Type - Dimensions - RSen_C_diameter: 7.87402 in; RSen_C_width_01: 10.2362 in; RSen_C_width_02: 3.93701 in; RSen_C_width_03: 9.52756 in; RSen_C_width_04: 9.92126 in
Type - General - installation_manual: https://acoswm.com/drain/klassikdrain/k100/; instructions_for_use: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 20-01-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_intended_use: Drainage systems
Type - Identity Data - Address: ACO, Inc. USA; Description: K2-906G In-Line catch basin w/ polymer concrete base; email sales: info@acousa.com; email Technical: info@acousa.com; Manufacturer: ACO; Model: K200/KS200 Catch Basin (0.5m); OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Name: K2-906G Catch Basin (0.5m); URL: www.acousa.com
Type - Materials and Finishes - RSen_C_material: Steel, Galvanised; RSen_C_material_01: polymer concrete; RSen_C_material_02: PE, Black
Type - Text - lookup_table_name: K2-906GS_Catch Basin_CAN
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: K2-906G Catch Basin (0.5m); sets with these values: 2
Other - DN_100_sanitary_check: no; DN_150_sanitary_check: yes; DN_sanitary: yes; Family: KlassikDrain_K2-906GS_Catch_basin_USA; Family and Type: KlassikDrain_K2-906GS_Catch_basin_USA: K2-906G Catch Basin (0.5m); OD_sanitary: no; outlet_DN100: no; outlet_DN150: yes; Type: K2-906G Catch Basin (0.5m); Type Id: 367037; universal_endcap_left: no; universal_endcap_right: no
Constraints - Elevation from Level: 0 in; gratings: KlassikDrain_K200_catch_basin_gratings_USA : Type 660D Ductile iron slotted (0.5m); Host: Level : Level 1; Level: Level 1; Offset from Host: 0 in; QuickLok_Locking_Bar: no
Dimensions - Area: 1.17241 m2; Brickslot_height_calculated: 0 in; cap thickness: 0.0787402 in; channel_inside_width: 7.87402 in; h1: 8.77953 in; h2: 8.85827 in; overall_in-line_pit_height: 32.874 in; r1: 0 in; rail: 0.984252 in; RSen_C_diameter_01: 2.95276 in; Volume: 0.0700553 m3
General - RSen_P_c01_diameter: 3.93701 in; RSen_P_c02_diameter: 5.90551 in
Identity Data - Mark: 5; productrange: KlassikDrain; RSen_C_code_article: 97937; RSen_C_code_gtin: -; RSen_C_description: K2-906G In-Line catch basin w/ polymer concrete base
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 62.18 kg

# IfcFlowTerminal: ZZZ_do not use_PF_ST_K200_catch_basin_gratings_USA:std(nested), ZZZ_do not use_PF_ST_K200_catch_basin_gratings_USA:std(nested):367059
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K100; Material: Iron, Ductile
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_K200_catch_basin_gratings_USA; lookup_table_name: gratings_K200_Catch_basin_CAN
Type - Constraints - Default Elevation: 0.333333 in
Type - General - RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/; RSen_C_intended_use: https://acoswm.com/drain/klassikdrain/
Type - Identity Data - Address: ACO, Inc. USA; Description: ACO Grating for KlassikDrain_K100; email-sales: info@acousa.com; email-Technical: info@acousa.com; LOD: LOD 300; Manufacturer: ACO; Model: Grating for KlassikDrain_K200; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Comments: --; Type Name: std(nested); URL: www.acousa.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - angle_left_calculated: 0 deg; angle_right_calculated: 0 deg; angle1_over_length_left: 0 in; angle1_over_length_right: 0 in; angle2_over_length_left: 0 in; angle2_over_length_right: 0 in; Brickslot_visible: no; Family: ZZZ_do not use_PF_ST_K200_catch_basin_gratings_USA; Family and Type: ZZZ_do not use_PF_ST_K200_catch_basin_gratings_USA: std(nested); Grate_visible: yes; IsCustom: no; length_1000_check: no; length_500_check: no; length_calculated: 19.685 in; product_index: 4; RSen_C_length_01: 19.685 in; RSen_C_width: 9.37008 in; Type: std(nested); type_index: 4; Type Id: 366858; visible: no
Constraints - Level: Level 1; Elevation from Level: 3.26772 in; Host: Level : Level 1; Moves With Nearby Elements: no; Offset from Host: 3.26772 in; RSen_C_angle_01: 0 deg; RSen_C_angle_02: 0 deg; RSen_C_length: 19.685 in
Dimensions - Brickslot_height_calculated: 0 in; angle_max: 90 deg; angle_min: -90 deg; Area: 0.247972 m2; Brickslot_width: 0.629921 in; D_L1: 19.685 in; D_L2: 19.685 in; D_R1: 39.3701 in; D_R2: 39.3701 in; insertion_point: 29.5276 in; RSen_C_width_01: 9.37008 in; Twinslot_200_distance: 0 in; U_L1: 19.685 in; U_L2: 19.685 in; U_R1: 39.3701 in; U_R2: 39.3701 in; Volume: 0.00357 m3
General - RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 23-01-2026; RSen_C_content_version: 1.0
Identity Data - Mark: 6; productrange: KlassikDrain; RSen_C_code_article: 142177; RSen_C_description: Type 660D Ductile iron slotted; Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Materials and Finishes - RSen_C_material: Iron, Ductile
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 8.618 kg

Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: d505bb93-9288-4e9b-8c69-b7034156cb0d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 97917.ifc
Time: 2026-03-02T14:25:24+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 in
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (in) = Constraints, Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcDistributionPort (7)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_379502_1
OutPort_379502_2
OutPort_379502_3
OutPort_379502_4
OutPort_379502_5
OutPort_379502_6
OutPort_379502_7

# IfcFlowTerminal: KlassikDrain_K2-622GS_Catch_basin_USA:K2-622G Catch Basin (0.5m), KlassikDrain_K2-622GS_Catch_basin_USA:K2-622G Catch Basin (0.5m):379502
In: Level 1
Type - Description: K2-622G catch basin w/ polymer concrete base; PredefinedType: USERDEFINED; Material: polymer concrete, PE, Black, Steel, Galvanised
Type - Other - Category: Plumbing Fixtures; Family Name: KlassikDrain_K2-622GS_Catch_basin_USA; material_index: 1
Type - Constraints - Default Elevation: 0 in; RSen_C_length_02: 19.685 in
Type - Dimensions - Brickslot_height_calculated: 0 in; RSen_C_diameter: 7.87402 in; RSen_C_width_01: 13.8583 in; RSen_C_width_02: 3.93701 in; RSen_C_width_03: 13.4646 in; RSen_C_width_04: 13.8583 in
Type - General - installation_manual: https://acoswm.com/drain/klassikdrain/k100/; instructions_for_use: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 20-01-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_intended_use: Drainage systems
Type - Identity Data - Address: ACO, Inc. USA; Description: K2-622G catch basin w/ polymer concrete base; email sales: info@acousa.com; email Technical: info@acousa.com; Manufacturer: ACO; Model: K200/KS200 Catch Basin (0.5m); OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Name: K2-622G Catch Basin (0.5m); URL: www.acousa.com
Type - Materials and Finishes - RSen_C_material: Steel, Galvanised; RSen_C_material_01: polymer concrete; RSen_C_material_02: PE, Black
Type - Text - lookup_table_name: K2-622GS Catch Basin_CAN
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: K2-622G Catch Basin (0.5m); sets with these values: 2
Other - DN_100_sanitary_check: no; DN_150_sanitary_check: yes; DN_sanitary: yes; Family: KlassikDrain_K2-622GS_Catch_basin_USA; Family and Type: KlassikDrain_K2-622GS_Catch_basin_USA: K2-622G Catch Basin (0.5m); OD_sanitary: no; outlet_DN100: no; outlet_DN150: yes; Type: K2-622G Catch Basin (0.5m); Type Id: 379481; universal_endcap_left: no; universal_endcap_right: no
Constraints - Elevation from Level: 0 in; gratings: 12_inch_wide_catch_basin_gratings : Series_600_Grates_DrainLok; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 in; QuickLok_Locking_Bar: yes
Dimensions - Area: 1.40587 m2; cap thickness: 0.0787402 in; channel_inside_width: 7.87402 in; h1: 8.77953 in; h2: 8.85827 in; overall_in-line_pit_height: 37.6378 in; r1: 0 in; rail: 0.984252 in; RSen_C_diameter_01: 2.95276 in; Volume: 0.0819227 m3
General - RSen_P_c01_diameter: 3.93701 in; RSen_P_c02_diameter: 5.90551 in
Identity Data - Mark: 12; productrange: KlassikDrain; RSen_C_code_article: 97917; RSen_C_code_gtin: -; RSen_C_description: K2-622G catch basin w/ polymer concrete base
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 76.97 kg

# IfcFlowTerminal: ZZZ_do not use_12_inch_wide_catch_basin_gratings:std(nested), ZZZ_do not use_12_inch_wide_catch_basin_gratings:std(nested):379503
In: Level 1
Type - Material: Steel, Galvanised
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_12_inch_wide_catch_basin_gratings
Type - Constraints - Default Elevation: 0 in
Type - Dimensions - length: 19.685 in; width: 13.3858 in
Type - General - RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 14-01-2026
Type - Identity Data - Type Name: std(nested); URL: www.acousa.com
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - Family: ZZZ_do not use_12_inch_wide_catch_basin_gratings; Family and Type: ZZZ_do not use_12_inch_wide_catch_basin_gratings: std(nested); Type: std(nested); type_index: 1; Type Id: 379366
Constraints - Elevation from Level: 0 in; Level: Level 1; Offset from Host: 0 in; Host: Level : Level 1; Moves With Nearby Elements: no
Dimensions - Area: 0.1952 m2; Volume: 0.0051 m3
Identity Data - Mark: 13; RSen_C_code_article: 0; RSen_C_description: Series 600 Grates DrainLok
Materials and Finishes - RSen_C_material: Steel, Galvanised
Phasing - Phase Created: New Construction

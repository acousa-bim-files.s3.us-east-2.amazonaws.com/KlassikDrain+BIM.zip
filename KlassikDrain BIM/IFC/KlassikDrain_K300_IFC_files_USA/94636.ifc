Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: d505bb93-9288-4e9b-8c69-b7034156cb0d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 94636.ifc
Time: 2026-03-02T17:08:47+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 in
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (in) = Constraints, Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcDistributionPort (15)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_473209_1
OutPort_473209_2
OutPort_473209_4
OutPort_473209_5
OutPort_473209_6
OutPort_473209_7
OutPort_473209_8
OutPort_473209_9
OutPort_473209_10
OutPort_473209_11
OutPort_473209_12
OutPort_473209_13
OutPort_473209_14
OutPort_473209_15
OutPort_473209_16

# IfcFlowTerminal: KlassikDrain_K3-904GS_Catch_basin_USA:KS3-904S Catch Basin(0.5m), KlassikDrain_K3-904GS_Catch_basin_USA:KS3-904S Catch Basin(0.5m):473209
In: Level 1
Type - Description: KS3- 904S In-Line catch basin w/ plastic riser & base; PredefinedType: USERDEFINED; Material: PE, Black, polymer concrete, Steel, Stainless
Type - Other - Category: Plumbing Fixtures; Family Name: KlassikDrain_K3-904GS_Catch_basin_USA; material_index: 1
Type - Constraints - Default Elevation: 0 in; RSen_C_length_02: 19.685 in
Type - Dimensions - RSen_C_diameter: 7.87402 in; RSen_C_width_01: 13.8583 in; RSen_C_width_02: 3.93701 in; RSen_C_width_03: 13.4646 in; RSen_C_width_04: 13.8583 in
Type - General - installation_manual: https://acoswm.com/drain/klassikdrain/k100/; instructions_for_use: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 20-01-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/k100/; RSen_C_intended_use: Drainage systems
Type - Identity Data - Address: ACO, Inc. USA; Description: KS3- 904S In-Line catch basin w/ plastic riser & base; email sales: info@acousa.com; email Technical: info@acousa.com; Manufacturer: ACO; Model: K300/KS300 Catch Basin (0.5m); OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Name: KS3-904S Catch Basin(0.5m); URL: www.acousa.com
Type - Materials and Finishes - RSen_C_material: Steel, Stainless; RSen_C_material_01: polymer concrete; RSen_C_material_02: PE, Black
Type - Text - lookup_table_name: K3-904GS Catch Basin_CAN
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: KS3-904S Catch Basin(0.5m); sets with these values: 2
Other - DN_100_sanitary_check: no; DN_150_sanitary_check: yes; DN_sanitary: yes; Family: KlassikDrain_K3-904GS_Catch_basin_USA; Family and Type: KlassikDrain_K3-904GS_Catch_basin_USA: KS3-904S Catch Basin(0.5m); OD_sanitary: no; outlet_DN100: no; outlet_DN150: yes; Plastic_Riser_cutting_size: 5; Riser_Depth_calculated: 12.0079 in; Type: KS3-904S Catch Basin(0.5m); Type Id: 473160; universal_endcap_left: no; universal_endcap_right: no
Constraints - Elevation from Level: 0 in; Foul_Air_trap: yes; gratings: KlassikDrain_K300_Inline_pit_gratings_USA : Type 805D Galvanized mesh (0.5 m); Host: Level : Level 1; Level: Level 1; Offset from Host: 0 in; QuickLok_Locking_Bar: yes; Riser_Depth: 12.2 in; Riser_Visibility: yes
Dimensions - Area: 1.53047 m2; cap thickness: 0.0787402 in; channel_inside_width: 11.811 in; h1: 8.77953 in; h2: 8.85827 in; overall_in-line_pit_height: 37.6378 in; r1: 0 in; rail: 0.984252 in; RSen_C_diameter_01: 2.95276 in; Volume: 0.0984829 m3
General - RSen_P_c01_diameter: 3.93701 in; RSen_P_c02_diameter: 5.90551 in
Identity Data - Mark: 65; productrange: KlassikDrain; RSen_C_code_article: 94636; RSen_C_code_gtin: -; RSen_C_description: KS3- 904S In-Line catch basin w/ plastic riser & base
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 44.4 kg

# IfcFlowTerminal: ZZZ_do not use_PF_ST_K300_Inline_pit_gratings_USA_ACO:std(nested), ZZZ_do not use_PF_ST_K300_Inline_pit_gratings_USA_ACO:std(nested):473217
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K200; Material: Steel, Galvanised
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_K300_Inline_pit_gratings_USA_ACO; lookup_table_name: K300_Inline_pit_gratings_CAN
Type - Constraints - Default Elevation: 0.333333 in
Type - Identity Data - Address: ACO, Inc. USA; Description: ACO Grating for KlassikDrain_K200; LOD: LOD 300; Manufacturer: ACO; Model: Grating for KlassikDrain_K200; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Comments: --; Type Name: std(nested); URL: www.acousa.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - Type: std(nested); angle_left_calculated: 0 deg; angle_right_calculated: 0 deg; angle1_over_length_left: 0 in; angle1_over_length_right: 0 in; angle2_over_length_left: 0 in; angle2_over_length_right: 0 in; Family: ZZZ_do not use_PF_ST_K300_Inline_pit_gratings_USA_ACO; Family and Type: ZZZ_do not use_PF_ST_K300_Inline_pit_gratings_USA_ACO: std(nested); Grate_visibility: yes; IsCustom: no; length_1000_check: no; length_500_check: no; length_calculated: 19.685 in; product_index: 2; RSen_C_length_01: 19.685 in; RSen_C_width: 13.3071 in; type_index: 2; Type Id: 472963; visible: no
Constraints - Elevation from Level: 0 in; Level: Level 1; Offset from Host: 0 in; Moves With Nearby Elements: no; Host: Level : Level 1; RSen_C_angle_01: 0 deg; RSen_C_angle_02: 0 deg; RSen_C_length: 19.685 in
Dimensions - angle_max: 90 deg; angle_min: -90 deg; Area: 0.199316 m2; D_L1: 19.685 in; D_L2: 19.685 in; D_R1: 39.3701 in; D_R2: 39.3701 in; insertion_point: 29.5276 in; RSen_C_width_01: 13.3071 in; U_L1: 19.685 in; U_L2: 19.685 in; U_R1: 39.3701 in; U_R2: 39.3701 in; Volume: 0.00507 m3
General - RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 09-02-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/; RSen_C_intended_use: https://acoswm.com/drain/klassikdrain/
Identity Data - email-sales: info@acocan.ca; email-Technical: info@acocan.ca; Mark: 73; productrange: KlassikDrain; RSen_C_code_article: 133675; RSen_C_description: Type 805D Galvanized mesh (0.5 m); Uniclass 2015 Code: Ss_50_30_02; Uniclass 2015 Title: Rainwater drainage systems
Materials and Finishes - RSen_C_material: Steel, Galvanised
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 11.88 kg

# IfcFlowTerminal: ZZZ_do not use_PF_ST_K300_plastic_riser:std(nested) (5)
In: Level 1
Type - Description: Series 600 Plastic Riser; Material: PE, Black
Type - Other - Category: Plumbing Fixtures; Family Name: ZZZ_do not use_PF_ST_K300_plastic_riser
Type - Constraints - Default Elevation: 0 in
Type - Dimensions - r1: 0.19685 in; RSen_C_width_01: 13.3858 in; RSen_C_width_02: 7.87402 in; RSen_C_width_03: 9.92126 in; RSen_C_width_04: 9.33071 in
Type - General - installation_manual: https://acoswm.com/drain/klassikdrain/; instructions_for_use: https://acoswm.com/drain/klassikdrain/; RSen_C_code_specification_URL: https://acoswm.com/drain/klassikdrain/; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_content_date_changed: 13-01-2026; RSen_C_content_version: 1.0; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/; RSen_C_intended_use: Drainage systems
Type - Identity Data - Address: ACO, Inc. USA; Description: Series 600 Plastic Riser; email sales: info@acousa.com; email Technical: info@acousa.com; Manufacturer: ACO; Model: Series 600 Plastic Riser; OmniClass Number: 23.70.50.24; OmniClass Title: Rainwater Removal; Telephone: 1-800-543-4764; Type Name: std(nested); URL: www.acousa.com
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
Other - Riser_Visibility: yes; material_index: 1; Family: ZZZ_do not use_PF_ST_K300_plastic_riser; Family and Type: ZZZ_do not use_PF_ST_K300_plastic_riser: std(nested); product_index: 1; Type: std(nested); Type Id: 472951
Constraints - Level: Level 1; Host: Level : Level 1; Moves With Nearby Elements: no; RSen_C_length_02: 19.2913 in
Dimensions - Area: 0.21809 m2; h2: 12.7953 in; rail: 0.984252 in; Riser_depth: 1.69291 in; Volume: 0.0101718 m3
Identity Data - productrange: KlassikDrain; RSen_C_code_article: 99902; RSen_C_description: Series 600 Plastic Riser
Materials and Finishes - RSen_C_material: PE, Black
Phasing - Phase Created: New Construction
Structural - RSen_S_net_mass: 4.53592 kg
Name (ZZZ_do not use_PF_ST_K300_plastic_riser:std(nested):...) | Elevation from Level (in) = Offset from Host (in) | Mark
473210 | -31.5748 | 66
473211 | -29.0945 | 67
473212 | -26.6142 | 68
473213 | -24.1339 | 69
473214 | -21.6535 | 70
